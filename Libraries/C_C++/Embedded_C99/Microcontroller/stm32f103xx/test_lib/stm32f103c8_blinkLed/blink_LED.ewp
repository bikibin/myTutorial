# IAR project blink_LED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: D:\myTutorial\Libraries\C_C++\Embedded_C99\Microcontroller\stm32f103xx\test_lib\stm32f103c8_blinkLed\include; D:\myTutorial\Libraries\C_C++\Embedded_C99\Microcontroller\stm32f103xx\driver\include; D:\myTutorial\Libraries\C_C++\Embedded_C99\Microcontroller\0_common\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: blink_LED.srec
  ILINK.IlinkOutputFile: blink_LED.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    source/: main.c
